options:
  parameters:
    generate_options: qt_gui
    id: bpsk_ant_rx
    output_language: python
    title: BPSK File Transfer RX
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 1, 1, 1]'
    label: Freq Offset
    start: '-0.25'
    step: '0.001'
    stop: '0.25'
    value: '0.01'
  states: {state: disabled}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: Noise
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.1'
  states: {state: disabled}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 2, 1, 1]'
    label: Time Scale
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\UoM Directory\Semester_3\EN2130 Communication Design Project\Ant_SDR\bpsk_file_transfer\ant_rx\bpsk_receive.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Here we select the file needs to be transmitted
    file: bpsk_transmit.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Attenutaion is done as a volume control.
      Receiver can still distinguish -1 and 1.
    const: '0.5'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: |-
      Add a tag for each block of 64 bytes. (packet_len)
      So we know the starting point of a each packet.
      Same as grouping and having packet stream rather than a bit stream
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: postamble_size
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Tag
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Packet is generated.
      (Preamble+Header+Payload(includes CRC)+Postamble)
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '512'
    samples_per_second: '8000'
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Preamble
      Help receiver find the 
      beginning of a packet
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Postamble
      Help receiver find the 
      ending of a packet
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {state: disabled}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: |-
      Apply BPSK modulation
      Constellation object is created
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: |-
      Add CRC 
      32 bits / 4 more bytes are added
      length tag is now updated 
      to the current state
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Generate the header of the packet
    format: hdr
    len_tag_key: packet_len
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.1.10
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '64'
    port: '52002'
    type: TCP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: ANT_SDR-Receiver
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 24e8
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
      	#f.write("Hello\n"*50)
          for val in range(0x30, 0x3A):
              payload = chr(val) * self.payload_size
              f.write(payload)
    comment: Create transmit file
    section: init_before_blocks
  states: {state: disabled}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import filecmp

      if filecmp.cmp("bpsk_transmit.txt", "bpsk_receive.txt", shallow=False):
          print("Successful file transfer")
      else:
         print("Error: Transmit and Receive files differ")
    comment: Compare transmit and receive file
    section: main_after_stop
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_packet
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: This is the header
    stream_id: header
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: transmit
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    comment: |-
      This is the payload
      (with CRC)
    stream_id: payload
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_packet
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: transmit
  states: {state: disabled}
- name: virtual_source_5
  id: virtual_source
  parameters:
    comment: This where header comes to mux
    stream_id: header
  states: {state: disabled}
- name: virtual_source_6
  id: virtual_source
  parameters:
    comment: this is where the payload
    stream_id: payload
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_tag_gate_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [channels_channel_model_1, '0', qtgui_time_sink_x_0_0, '0']
- [channels_channel_model_1, '0', virtual_sink_2, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_2_0, '0']
- [digital_crc32_bb_1, '0', blocks_char_to_float_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_5, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_1, '0']
- [virtual_source_4, '0', channels_channel_model_1, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', blocks_tagged_stream_mux_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
